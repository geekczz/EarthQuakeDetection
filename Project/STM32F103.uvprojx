# Keil uVision project STM32F103.uvprojx, settings and files
target My Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\Driver;..\User;..\LIB\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h startup_stm32f10x_md.s
  group Driver
    ../Driver/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h BSP.c BSP.h ADXL313.c ADXL313.h FLASH.c FLASH.h RTC.c RTC.h LORA.h LORA.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_rtc.c
    ../../地震检测项目程序/LIB/src/: stm32f10x_bkp.c stm32f10x_pwr.c
  group User
    ../User/: GLOBAL.h main.c main.h
